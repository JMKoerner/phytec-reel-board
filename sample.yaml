## sample.yaml
```yaml
sample:
  description: reel board mesh badge sample
  name: mesh badge de
tests:
  test:
    platform_whitelist: reel_board
    tags: samples sensor
    harness: sensor
```
